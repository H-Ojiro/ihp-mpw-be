v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 620 -310 0 0 {name=L33
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=10u
s=5u
d=222u
nr_r=3}
C {local_gnd.sym} 650 -280 0 0 {name=l6 lab=VSUB}
C {iopin.sym} 620 -280 2 0 {name=p17 sig_type=std_logic lab=LB33}
C {iopin.sym} 620 -340 2 0 {name=p18 sig_type=std_logic lab=LA33}

v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 620 -540 0 0 {name=L31
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=10u
s=10u
d=222u
nr_r=3}
C {local_gnd.sym} 650 -510 0 0 {name=l4 lab=VSUB}
C {iopin.sym} 620 -510 2 0 {name=p9 sig_type=std_logic lab=LB31}
C {iopin.sym} 620 -570 2 0 {name=p10 sig_type=std_logic lab=LA31}

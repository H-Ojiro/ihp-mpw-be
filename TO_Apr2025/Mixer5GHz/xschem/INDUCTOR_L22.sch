v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 840 -420 0 0 {name=L22
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=5u
s=10u
d=222u
nr_r=2}
C {local_gnd.sym} 870 -390 0 0 {name=l9 lab=VSUB}
C {iopin.sym} 840 -390 2 0 {name=p13 sig_type=std_logic lab=LB22}
C {iopin.sym} 840 -450 2 0 {name=p14 sig_type=std_logic lab=LA22}

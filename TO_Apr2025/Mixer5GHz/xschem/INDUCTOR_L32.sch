v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 620 -420 0 0 {name=L32
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=5u
s=10u
d=222u
nr_r=3}
C {local_gnd.sym} 650 -390 0 0 {name=l5 lab=VSUB}
C {iopin.sym} 620 -390 2 0 {name=p15 sig_type=std_logic lab=LB32}
C {iopin.sym} 620 -450 2 0 {name=p16 sig_type=std_logic lab=LA32}

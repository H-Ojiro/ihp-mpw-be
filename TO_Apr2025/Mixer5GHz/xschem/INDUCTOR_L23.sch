v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 840 -310 0 0 {name=L23
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=10u
s=5u
d=222u
nr_r=2}
C {local_gnd.sym} 870 -280 0 0 {name=l10 lab=VSUB}
C {iopin.sym} 840 -280 2 0 {name=p19 sig_type=std_logic lab=LB23}
C {iopin.sym} 840 -340 2 0 {name=p20 sig_type=std_logic lab=LA23}

v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 400 -540 0 0 {name=L41
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=10u
s=10u
d=222u
nr_r=4}
C {local_gnd.sym} 430 -510 0 0 {name=l13 lab=VSUB}
C {iopin.sym} 400 -510 2 0 {name=p2 sig_type=std_logic lab=LB41}
C {iopin.sym} 400 -570 2 0 {name=p1 sig_type=std_logic lab=LA41}

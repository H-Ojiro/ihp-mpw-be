v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {inductor2.sym} 840 -190 0 0 {name=L24
m=1
value=1n
footprint=1206
device=inductor2
spiceprefix=X
w=5u
s=5u
d=222u
nr_r=2}
C {local_gnd.sym} 870 -160 0 0 {name=l11 lab=VSUB}
C {iopin.sym} 840 -160 2 0 {name=p21 sig_type=std_logic lab=LB24}
C {iopin.sym} 840 -220 2 0 {name=p22 sig_type=std_logic lab=LA24}

v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 850 -370 850 -340 {
lab=netq1}
N 770 -340 850 -340 {
lab=netq1}
N 690 -370 690 -340 {
lab=netq1}
N 610 -400 650 -400 {
lab=_net0}
N 690 -400 770 -400 {
lab=VSS}
N 770 -400 770 -390 {lab=VSS}
N 770 -400 850 -400 {lab=VSS}
N 610 -400 610 -330 {lab=_net0}
N 570 -400 610 -400 {lab=_net0}
N 690 -460 690 -430 {lab=_net1}
N 690 -460 850 -460 {lab=_net1}
N 850 -460 850 -430 {lab=_net1}
N 690 -590 690 -460 {lab=_net1}
N 450 -400 510 -400 {lab=RFIN}
N 610 -510 610 -400 {lab=_net0}
N 610 -510 920 -510 {lab=_net0}
N 920 -510 920 -400 {lab=_net0}
N 890 -400 920 -400 {
lab=_net0}
N 690 -590 740 -590 {lab=_net1}
N 1220 -560 1220 -530 {
lab=netq3}
N 1140 -530 1220 -530 {
lab=netq3}
N 1060 -560 1060 -530 {
lab=netq3}
N 1140 -590 1220 -590 {
lab=VSS}
N 1060 -650 1220 -650 {lab=_net3}
N 1220 -650 1220 -620 {lab=_net3}
N 1260 -590 1290 -590 {
lab=_net7}
N 840 -590 880 -590 {lab=_net2}
N 980 -590 1020 -590 {lab=_net7}
N 980 -590 980 -320 {lab=_net7}
N 940 -590 980 -590 {lab=_net7}
N 980 -270 980 -240 {lab=VBB1}
N 610 -240 980 -240 {lab=VBB1}
N 610 -270 610 -240 {lab=VBB1}
N 980 -700 980 -590 {lab=_net7}
N 980 -700 1290 -700 {lab=_net7}
N 1290 -700 1290 -590 {lab=_net7}
N 690 -1190 1060 -1190 {lab=VCC1B}
N 1060 -650 1060 -620 {lab=_net3}
N 1060 -1190 1060 -1140 {lab=VCC1B}
N 1060 -790 1060 -650 {lab=_net3}
N 690 -1080 690 -590 {lab=_net1}
N 1520 -790 1600 -790 {
lab=VSS}
N 1440 -850 1600 -850 {lab=_net6}
N 1600 -850 1600 -820 {lab=_net6}
N 1440 -850 1440 -820 {lab=_net6}
N 1520 -730 1600 -730 {lab=netq6}
N 1440 -760 1440 -730 {lab=netq6}
N 1600 -760 1600 -730 {lab=netq6}
N 1220 -790 1260 -790 {lab=_net4}
N 1370 -790 1400 -790 {lab=_net5}
N 1060 -790 1120 -790 {lab=_net3}
N 1060 -1080 1060 -790 {lab=_net3}
N 1140 -590 1140 -580 {lab=VSS}
N 1060 -590 1140 -590 {
lab=VSS}
N 1520 -790 1520 -780 {lab=VSS}
N 1440 -790 1520 -790 {
lab=VSS}
N 1440 -990 1440 -850 {lab=_net6}
N 1370 -900 1370 -790 {lab=_net5}
N 1320 -790 1370 -790 {lab=_net5}
N 1370 -900 1690 -900 {lab=_net5}
N 1690 -900 1690 -790 {lab=_net5}
N 1640 -790 1690 -790 {lab=_net5}
N 1370 -790 1370 -320 {lab=_net5}
N 1370 -260 1370 -240 {lab=VBB2}
N 1060 -1230 1060 -1190 {lab=VCC1B}
N 690 -1190 690 -1140 {lab=VCC1B}
N 1440 -990 1640 -990 {lab=_net6}
N 1440 -1090 1440 -990 {lab=_net6}
N 1870 -990 1920 -990 {lab=RFOUT}
N 850 -1570 850 -1540 {
lab=netq9}
N 770 -1540 850 -1540 {
lab=netq9}
N 690 -1570 690 -1540 {
lab=netq9}
N 610 -1600 650 -1600 {
lab=_net8}
N 690 -1600 770 -1600 {
lab=VSS}
N 770 -1600 770 -1590 {lab=VSS}
N 770 -1600 850 -1600 {lab=VSS}
N 610 -1600 610 -1530 {lab=_net8}
N 570 -1600 610 -1600 {lab=_net8}
N 690 -1660 690 -1630 {lab=_net9}
N 690 -1660 850 -1660 {lab=_net9}
N 850 -1660 850 -1630 {lab=_net9}
N 690 -1790 690 -1660 {lab=_net9}
N 610 -1710 610 -1600 {lab=_net8}
N 610 -1710 920 -1710 {lab=_net8}
N 920 -1710 920 -1600 {lab=_net8}
N 890 -1600 920 -1600 {
lab=_net8}
N 690 -1790 740 -1790 {lab=_net9}
N 1220 -1760 1220 -1730 {
lab=netq11}
N 1140 -1730 1220 -1730 {
lab=netq11}
N 1060 -1760 1060 -1730 {
lab=netq11}
N 1140 -1790 1220 -1790 {
lab=VSS}
N 1060 -1850 1220 -1850 {lab=_net11}
N 1220 -1850 1220 -1820 {lab=_net11}
N 1260 -1790 1290 -1790 {
lab=_net15}
N 1140 -1410 1520 -1410 {lab=VSS}
N 840 -1790 880 -1790 {lab=_net10}
N 980 -1790 1020 -1790 {lab=_net15}
N 980 -1790 980 -1520 {lab=_net15}
N 940 -1790 980 -1790 {lab=_net15}
N 980 -1470 980 -1440 {lab=VBB1}
N 610 -1440 980 -1440 {lab=VBB1}
N 610 -1470 610 -1440 {lab=VBB1}
N 980 -1900 980 -1790 {lab=_net15}
N 980 -1900 1290 -1900 {lab=_net15}
N 1290 -1900 1290 -1790 {lab=_net15}
N 690 -2390 1060 -2390 {lab=VCC1A}
N 1060 -1850 1060 -1820 {lab=_net11}
N 1060 -2390 1060 -2340 {lab=VCC1A}
N 1060 -1990 1060 -1850 {lab=_net11}
N 690 -2280 690 -1790 {lab=_net9}
N 1520 -1990 1600 -1990 {
lab=VSS}
N 1440 -2050 1600 -2050 {lab=_net14}
N 1600 -2050 1600 -2020 {lab=_net14}
N 1440 -2050 1440 -2020 {lab=_net14}
N 1520 -1930 1600 -1930 {
lab=netq14}
N 1440 -1960 1440 -1930 {lab=netq14}
N 1600 -1960 1600 -1930 {lab=netq14}
N 1220 -1990 1260 -1990 {lab=_net12}
N 1370 -1990 1400 -1990 {lab=_net13}
N 1060 -1990 1120 -1990 {lab=_net11}
N 1060 -2280 1060 -1990 {lab=_net11}
N 1140 -1790 1140 -1780 {lab=VSS}
N 1060 -1790 1140 -1790 {
lab=VSS}
N 1520 -1990 1520 -1980 {lab=VSS}
N 1440 -1990 1520 -1990 {
lab=VSS}
N 1440 -2190 1440 -2050 {lab=_net14}
N 1370 -2100 1370 -1990 {lab=_net13}
N 1320 -1990 1370 -1990 {lab=_net13}
N 1370 -2100 1690 -2100 {lab=_net13}
N 1690 -2100 1690 -1990 {lab=_net13}
N 1640 -1990 1690 -1990 {lab=_net13}
N 1370 -1990 1370 -1520 {lab=_net13}
N 1370 -1460 1370 -1440 {lab=VBB2}
N 1060 -2430 1060 -2390 {lab=VCC1A}
N 690 -2390 690 -2340 {lab=VCC1A}
N 1440 -2190 1640 -2190 {lab=_net14}
N 1440 -2290 1440 -2190 {lab=_net14}
N 450 -970 450 -400 {lab=RFIN}
N 450 -1600 510 -1600 {lab=RFIN}
N 1870 -1500 1870 -990 {lab=RFOUT}
N 1700 -2190 1870 -2190 {lab=RFOUT}
N 1700 -990 1870 -990 {lab=RFOUT}
N 390 -400 450 -400 {lab=RFIN}
N 1870 -1560 1920 -1560 {lab=RFOUT}
N 1870 -2190 1870 -1560 {lab=RFOUT}
N 1870 -1500 1920 -1500 {lab=RFOUT}
N 1870 -1560 1870 -1500 {lab=RFOUT}
N 400 -1030 450 -1030 {lab=RFIN}
N 450 -1600 450 -1030 {lab=RFIN}
N 400 -970 450 -970 {lab=RFIN}
N 450 -1030 450 -970 {lab=RFIN}
N 1440 -1230 1440 -1150 {lab=VCC2B}
N 1440 -2430 1440 -2350 {lab=VCC2A}
N 450 -400 450 -320 {lab=RFIN}
N 450 -260 450 -210 {lab=VSS}
N 1520 -210 1870 -210 {lab=VSS}
N 1870 -990 1870 -320 {lab=RFOUT}
N 1870 -260 1870 -210 {lab=VSS}
N 770 -340 770 -320 {lab=netq1}
N 690 -340 770 -340 {lab=netq1}
N 770 -260 770 -210 {lab=VSS}
N 450 -210 770 -210 {lab=VSS}
N 1140 -530 1140 -320 {lab=netq3}
N 1060 -530 1140 -530 {lab=netq3}
N 1140 -260 1140 -210 {lab=VSS}
N 1520 -730 1520 -320 {lab=netq6}
N 1440 -730 1520 -730 {lab=netq6}
N 1520 -260 1520 -210 {lab=VSS}
N 1140 -210 1520 -210 {lab=VSS}
N 840 -720 840 -590 {lab=_net2}
N 800 -590 840 -590 {lab=_net2}
N 770 -210 1140 -210 {lab=VSS}
N 1220 -900 1220 -790 {lab=_net4}
N 1180 -790 1220 -790 {lab=_net4}
N 770 -1540 770 -1530 {lab=netq9}
N 690 -1540 770 -1540 {lab=netq9}
N 770 -1470 770 -1410 {lab=VSS}
N 1140 -1470 1140 -1410 {lab=VSS}
N 770 -1410 1140 -1410 {lab=VSS}
N 1140 -1730 1140 -1530 {lab=netq11}
N 1060 -1730 1140 -1730 {lab=netq11}
N 1520 -1460 1520 -1410 {lab=VSS}
N 1520 -1930 1520 -1520 {lab=netq14}
N 1440 -1930 1520 -1930 {lab=netq14}
N 840 -1920 840 -1790 {lab=_net10}
N 800 -1790 840 -1790 {lab=_net10}
N 1220 -2100 1220 -1990 {lab=_net12}
N 1180 -1990 1220 -1990 {lab=_net12}
C {lab_wire.sym} 610 -450 0 0 {name=p10 sig_type=std_logic lab=_net0
}
C {iopin.sym} 170 -350 0 1 {name=p19 lab=VBB1}
C {local_gnd.sym} 770 -390 0 0 {name=l9 lab=VSS}
C {title.sym} 280 -90 0 0 {name=T1 author="H. Ojiro"}
C {iopin.sym} 170 -320 0 1 {name=p8 lab=VBB2}
C {sg13g2_pr/npn13G2.sym} 670 -400 0 0 {name=Qnpn13G1
model=npn13G2
spiceprefix=X
Nx=8}
C {sg13g2_pr/npn13G2.sym} 870 -400 0 1 {name=Qnpn13G2
model=npn13G2
spiceprefix=X
Nx=8}
C {sg13g2_pr/rsil.sym} 610 -300 0 0 {name=Rrsil1
w=2e-6
l=11e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {sg13g2_pr/cap_rfcmim.sym} 540 -400 3 0 {name=Ccap_rfcmim1
model=cap_rfcmim
w=4.6e-6
l=4.2e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {local_gnd.sym} 540 -370 0 0 {name=l3 lab=VSS}
C {lab_wire.sym} 690 -550 0 0 {name=p12 sig_type=std_logic lab=_net1
}
C {sg13g2_pr/rppd.sym} 690 -1110 0 0 {name=Rrppd2
w=35e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {ipin.sym} 390 -400 0 0 {name=p1 lab=RFIN}
C {sg13g2_pr/cap_rfcmim.sym} 770 -590 3 0 {name=Ccap_rfcmim3
model=cap_rfcmim
w=6.6e-6
l=6.1e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {local_gnd.sym} 1140 -580 0 0 {name=l1 lab=VSS}
C {sg13g2_pr/npn13G2.sym} 1040 -590 0 0 {name=Qnpn13G3
model=npn13G2
spiceprefix=X
Nx=8}
C {sg13g2_pr/npn13G2.sym} 1240 -590 0 1 {name=Qnpn13G4
model=npn13G2
spiceprefix=X
Nx=8}
C {lab_wire.sym} 1060 -730 0 0 {name=p7 sig_type=std_logic lab=_net3
}
C {lab_wire.sym} 980 -640 0 0 {name=p4 sig_type=std_logic lab=_net7
}
C {sg13g2_pr/cap_rfcmim.sym} 910 -590 3 0 {name=Ccap_rfcmim4
model=cap_rfcmim
w=4.6e-6
l=4.5e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {lab_wire.sym} 840 -590 0 0 {name=p5 sig_type=std_logic lab=_net2
}
C {sg13g2_pr/rsil.sym} 980 -300 0 0 {name=Rrsil2
w=2e-6
l=11e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_gnd.sym} 610 -240 0 0 {name=l4 lab=VBB1}
C {local_gnd.sym} 770 -560 0 0 {name=l5 lab=VSS}
C {local_gnd.sym} 910 -560 0 0 {name=l6 lab=VSS}
C {sg13g2_pr/rppd.sym} 1060 -1110 0 0 {name=Rrppd1
w=35e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_gnd.sym} 1520 -780 0 0 {name=l7 lab=VSS}
C {sg13g2_pr/npn13G2.sym} 1420 -790 0 0 {name=Qnpn13G5
model=npn13G2
spiceprefix=X
Nx=10}
C {sg13g2_pr/npn13G2.sym} 1620 -790 0 1 {name=Qnpn13G6
model=npn13G2
spiceprefix=X
Nx=10
}
C {sg13g2_pr/cap_rfcmim.sym} 1150 -790 3 0 {name=Ccap_rfcmim5
model=cap_rfcmim
w=6.6e-6
l=5.3e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {sg13g2_pr/cap_rfcmim.sym} 1290 -790 3 0 {name=Ccap_rfcmim6
model=cap_rfcmim
w=4.9e-6
l=4.3e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {lab_wire.sym} 1220 -790 0 0 {name=p9 sig_type=std_logic lab=_net4
}
C {local_gnd.sym} 1150 -760 0 0 {name=l8 lab=VSS}
C {local_gnd.sym} 1290 -760 0 0 {name=l10 lab=VSS}
C {lab_wire.sym} 1370 -840 0 0 {name=p11 sig_type=std_logic lab=_net5
}
C {sg13g2_pr/rppd.sym} 1440 -1120 0 0 {name=Rrppd3
w=35e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {lab_wire.sym} 1440 -920 0 0 {name=p13 sig_type=std_logic lab=_net6
}
C {sg13g2_pr/rsil.sym} 1370 -290 0 0 {name=Rrsil3
w=2e-6
l=12e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_gnd.sym} 1370 -240 0 0 {name=l11 lab=VBB2}
C {iopin.sym} 170 -410 0 1 {name=p14 lab=VCC1B}
C {iopin.sym} 170 -380 0 1 {name=p15 lab=VCC2B}
C {iopin.sym} 170 -290 0 1 {name=p16 lab=VSS}
C {sg13g2_pr/cap_rfcmim.sym} 1670 -990 3 0 {name=Ccap_rfcmim7
model=cap_rfcmim
w=5.2e-6
l=4.8e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {opin.sym} 1920 -990 0 0 {name=p17 lab=RFOUT}
C {lab_wire.sym} 610 -1650 0 0 {name=p3 sig_type=std_logic lab=_net8
}
C {local_gnd.sym} 770 -1590 0 0 {name=l12 lab=VSS}
C {sg13g2_pr/npn13G2.sym} 670 -1600 0 0 {name=Qnpn13G7
model=npn13G2
spiceprefix=X
Nx=8}
C {sg13g2_pr/npn13G2.sym} 870 -1600 0 1 {name=Qnpn13G8
model=npn13G2
spiceprefix=X
Nx=8}
C {sg13g2_pr/rsil.sym} 610 -1500 0 0 {name=Rrsil7
w=2e-6
l=11e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {sg13g2_pr/cap_rfcmim.sym} 540 -1600 3 0 {name=Ccap_rfcmim8
model=cap_rfcmim
w=4.6e-6
l=4.2e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {local_gnd.sym} 540 -1570 0 0 {name=l13 lab=VSS}
C {lab_wire.sym} 690 -1750 0 0 {name=p18 sig_type=std_logic lab=_net9
}
C {sg13g2_pr/rppd.sym} 690 -2310 0 0 {name=Rrppd4
w=35e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {sg13g2_pr/cap_rfcmim.sym} 770 -1790 3 0 {name=Ccap_rfcmim9
model=cap_rfcmim
w=6.6e-6
l=6.1e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {local_gnd.sym} 1140 -1780 0 0 {name=l14 lab=VSS}
C {sg13g2_pr/npn13G2.sym} 1040 -1790 0 0 {name=Qnpn13G9
model=npn13G2
spiceprefix=X
Nx=8}
C {sg13g2_pr/npn13G2.sym} 1240 -1790 0 1 {name=Qnpn13G10
model=npn13G2
spiceprefix=X
Nx=8}
C {lab_wire.sym} 1060 -1930 0 0 {name=p21 sig_type=std_logic lab=_net11
}
C {local_gnd.sym} 1140 -1410 0 0 {name=l15 lab=VSS}
C {lab_wire.sym} 980 -1840 0 0 {name=p22 sig_type=std_logic lab=_net15
}
C {sg13g2_pr/cap_rfcmim.sym} 910 -1790 3 0 {name=Ccap_rfcmim10
model=cap_rfcmim
w=4.6e-6
l=4.5e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {lab_wire.sym} 840 -1790 0 0 {name=p23 sig_type=std_logic lab=_net10
}
C {sg13g2_pr/rsil.sym} 980 -1500 0 0 {name=Rrsil8
w=2e-6
l=11e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_gnd.sym} 610 -1440 0 0 {name=l16 lab=VBB1}
C {local_gnd.sym} 770 -1760 0 0 {name=l17 lab=VSS}
C {local_gnd.sym} 910 -1760 0 0 {name=l18 lab=VSS}
C {sg13g2_pr/rppd.sym} 1060 -2310 0 0 {name=Rrppd5
w=35e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_gnd.sym} 1520 -1980 0 0 {name=l19 lab=VSS}
C {sg13g2_pr/npn13G2.sym} 1420 -1990 0 0 {name=Qnpn13G11
model=npn13G2
spiceprefix=X
Nx=10}
C {sg13g2_pr/npn13G2.sym} 1620 -1990 0 1 {name=Qnpn13G12
model=npn13G2
spiceprefix=X
Nx=10
}
C {sg13g2_pr/cap_rfcmim.sym} 1150 -1990 3 0 {name=Ccap_rfcmim11
model=cap_rfcmim
w=6.6e-6
l=5.3e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {sg13g2_pr/cap_rfcmim.sym} 1290 -1990 3 0 {name=Ccap_rfcmim12
model=cap_rfcmim
w=4.9e-6
l=4.3e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {lab_wire.sym} 1220 -1990 0 0 {name=p25 sig_type=std_logic lab=_net12
}
C {local_gnd.sym} 1150 -1960 0 0 {name=l20 lab=VSS}
C {local_gnd.sym} 1290 -1960 0 0 {name=l21 lab=VSS}
C {lab_wire.sym} 1370 -2040 0 0 {name=p26 sig_type=std_logic lab=_net13
}
C {sg13g2_pr/rppd.sym} 1440 -2320 0 0 {name=Rrppd6
w=35e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {lab_wire.sym} 1440 -2120 0 0 {name=p27 sig_type=std_logic lab=_net14
}
C {sg13g2_pr/rsil.sym} 1370 -1490 0 0 {name=Rrsil9
w=2e-6
l=12e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_gnd.sym} 1370 -1440 0 0 {name=l22 lab=VBB2}
C {sg13g2_pr/cap_rfcmim.sym} 1670 -2190 3 0 {name=Ccap_rfcmim13
model=cap_rfcmim
w=5.2e-6
l=4.8e-6
wfeed=3.0e-6
spiceprefix=X
lvs_format="@spiceprefix@name @pinlist @lvs_model w=@w l=@l wfeed=@wfeed"
lvs_model=rfcmim}
C {local_gnd.sym} 1670 -960 0 0 {name=l23 lab=VSS}
C {local_gnd.sym} 1670 -2160 0 0 {name=l24 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2200 -2010 0 0 {name=Ccap_cmim1
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2200 -1980 0 0 {name=l25 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2370 -2010 0 0 {name=Ccap_cmim2
model=cap_cmim
w=10.5e-6
l=14.885e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2370 -1980 0 0 {name=l26 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2540 -2010 0 0 {name=Ccap_cmim3
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2540 -1980 0 0 {name=l27 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2710 -2010 0 0 {name=Ccap_cmim4
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2710 -1980 0 0 {name=l28 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2880 -2010 0 0 {name=Ccap_cmim5
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2880 -1980 0 0 {name=l29 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 3050 -2010 0 0 {name=Ccap_cmim6
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 3050 -1980 0 0 {name=l30 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2200 -800 0 0 {name=Ccap_cmim7
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2200 -770 0 0 {name=l31 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2370 -800 0 0 {name=Ccap_cmim8
model=cap_cmim
w=10.5e-6
l=14.885e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2370 -770 0 0 {name=l32 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2540 -800 0 0 {name=Ccap_cmim9
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2540 -770 0 0 {name=l33 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2710 -800 0 0 {name=Ccap_cmim10
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2710 -770 0 0 {name=l34 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 2880 -800 0 0 {name=Ccap_cmim11
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 2880 -770 0 0 {name=l35 lab=VSS}
C {sg13g2_pr/cap_cmim.sym} 3050 -800 0 0 {name=Ccap_cmim12
model=cap_cmim
w=10.5e-6
l=15.0e-6
m=1
spiceprefix=X}
C {local_gnd.sym} 3050 -770 0 0 {name=l36 lab=VSS}
C {sg13g2_pr/rsil.sym} 1920 -1530 0 0 {name=Rrsil14
w=2.04e-6
l=28e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {sg13g2_pr/rsil.sym} 400 -1000 0 1 {name=Rrsil13
w=2.04e-6
l=28e-6
model=rsil
body=sub!
spiceprefix=X
b=0
m=1
lvs_format="@spiceprefix@name @pinlist @model w=@w l=@l m=@m b=@b"
}
C {local_vdd.sym} 1060 -2430 0 0 {name=l37 lab=VCC1A}
C {local_vdd.sym} 1440 -1230 0 0 {name=l39 lab=VCC2B}
C {local_vdd.sym} 1060 -1230 0 0 {name=l40 lab=VCC1B}
C {local_vdd.sym} 2200 -2040 0 0 {name=l41 lab=VCC1A}
C {local_vdd.sym} 2370 -2040 0 0 {name=l42 lab=VCC1A}
C {local_vdd.sym} 2540 -2040 0 0 {name=l43 lab=VCC1A}
C {local_vdd.sym} 2710 -2040 0 0 {name=l44 lab=VCC1A}
C {local_vdd.sym} 2880 -2040 0 0 {name=l45 lab=VCC2A}
C {local_vdd.sym} 3050 -2040 0 0 {name=l46 lab=VCC2A}
C {local_vdd.sym} 2200 -830 0 0 {name=l47 lab=VCC1B}
C {local_vdd.sym} 2370 -830 0 0 {name=l48 lab=VCC1B}
C {local_vdd.sym} 2540 -830 0 0 {name=l49 lab=VCC1B}
C {local_vdd.sym} 2710 -830 0 0 {name=l50 lab=VCC1B}
C {local_vdd.sym} 2880 -830 0 0 {name=l51 lab=VCC2B}
C {local_vdd.sym} 3050 -830 0 0 {name=l52 lab=VCC2B}
C {iopin.sym} 170 -1690 0 1 {name=p20 lab=VCC1A}
C {iopin.sym} 170 -1660 0 1 {name=p24 lab=VCC2A}
C {local_vdd.sym} 1440 -2430 0 0 {name=l38 lab=VCC2A}
C {res_topmetal2.sym} 450 -290 0 0 {name=RRFIN
w=15e-6
l=40.6e-6
model=res_topmetal2
spiceprefix=X
m=2
}
C {res_topmetal2.sym} 1870 -290 0 0 {name=RRFOUT
w=15e-6
l=73.1e-6
model=res_topmetal2
spiceprefix=X
m=2
}
C {res_topmetal2.sym} 770 -290 0 0 {name=RRM1
w=15e-6
l=7.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {res_topmetal2.sym} 1140 -290 0 0 {name=RRM2
w=15e-6
l=7.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {res_topmetal2.sym} 1520 -290 0 0 {name=RRM3
w=15e-6
l=7.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {res_topmetal2.sym} 840 -750 2 0 {name=RRM4
w=15e-6
l=18.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {local_gnd.sym} 1140 -210 0 0 {name=l53 lab=VSS}
C {local_gnd.sym} 840 -780 2 0 {name=l2 lab=VSS}
C {res_topmetal2.sym} 1220 -930 2 0 {name=RRM5
w=15e-6
l=18.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {local_gnd.sym} 1220 -960 2 0 {name=l54 lab=VSS}
C {res_topmetal2.sym} 770 -1500 0 0 {name=RRM6
w=15e-6
l=7.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {res_topmetal2.sym} 1140 -1500 0 0 {name=RRM7
w=15e-6
l=7.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {res_topmetal2.sym} 1520 -1490 0 0 {name=RRM8
w=15e-6
l=7.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {res_topmetal2.sym} 840 -1950 2 0 {name=RRM9
w=15e-6
l=18.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {local_gnd.sym} 840 -1980 2 0 {name=l55 lab=VSS}
C {res_topmetal2.sym} 1220 -2130 2 0 {name=RRM10
w=15e-6
l=18.1e-6
model=res_topmetal2
spiceprefix=X
m=1
}
C {local_gnd.sym} 1220 -2160 2 0 {name=l56 lab=VSS}
C {lab_wire.sym} 750 -340 0 0 {name=p2 sig_type=std_logic lab=netq1
}
C {lab_wire.sym} 1120 -530 0 0 {name=p6 sig_type=std_logic lab=netq3
}
C {lab_wire.sym} 1500 -730 0 0 {name=p28 sig_type=std_logic lab=netq6
}
C {lab_wire.sym} 1500 -1930 0 0 {name=p29 sig_type=std_logic lab=netq14
}
C {lab_wire.sym} 1110 -1730 0 0 {name=p30 sig_type=std_logic lab=netq11
}
C {lab_wire.sym} 740 -1540 0 0 {name=p31 sig_type=std_logic lab=netq9
}
